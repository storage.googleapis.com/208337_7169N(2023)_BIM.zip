Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2023-06-23T20:37:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 23 20:37:53 2023 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\c1509cd4-2cff-47e7-9d31-166233680e6a\84404339-db1d-4e94-98e7-014c8aff3190\ifc * Database version: 5507 * Database creation date: Fri Jun 23 20:37:51 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 23 20:37:51 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 23 20:37:51 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 7169N Shower faucet with shower set, 7169N(2023):7169N Shower faucet with shower set:14964
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 87 mm; FaucetNominalHeight: 100.184 mm; FaucetNominalWidth: 342.373 mm; HandShowerNominalDepth: 124.45 mm; HandShowerNominalHeight: 765.13 mm; HandShowerNominalWidth: 236.108 mm
Type - General - Author: BIMStone; BIMObjectName: 7169N(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - EAN Number: 6414150099526; EN Standard: EN1111; ETIM Class Number: EC011329 Shower mixing tap; Noise Class 02ls: I (ISO 3822); Sales Package dimensions (LxWxH): 781 x 241 x 79; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/7169N; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/7169N
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/7169N; 3D View: https://static.oras.com/AR/7169N; Catalog Drawing URL: http://static.oras.com/catdrw/7169N; Dimension Drawing URL: http://static.oras.com/dimdrw/7169N; FDV Document URL: http://www.oras.com/datasheet/7169N/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7169N; Group: Shower faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/7169N; Interactive AR View URL: https://static.oras.com/AR/7169N; Manufacturer: Oras; Market: Denmark;Finland;International; Mobile Product Information URL: http://mpi.oras.com/7169N; Model: 7169N Shower faucet with shower set; Name_en: 7169N Shower faucet with shower set; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 7169N; Product Family: Oras Optima; Product Image URL: http://static.oras.com/image/7169N; Product URL: http://static.oras.com/7169N; Technical DataSheet URL: http://www.oras.com/datasheet/7169N/en; Type Name: 7169N Shower faucet with shower set; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Flexible length / can be shortened;Hose guide, revolving; Backflow Prevention EN1717: EB; Connection: Straight coupling(s);Direct connection; Connection Size: G3/4; Eco Flow At 300kPa: 0.00423776 m3/s; Excluded Items: Without couplings; Flow Rate At 300kPa: 0.00776923 m3/s; Hand Shower Size: Ø110; Installation Type: Wall mounted; Installation Width: CC150± 3 mm; Lever Handle: Temperature control handle;Flow control handle;Hot/Cold symbols;Easy-Grip surface;Eco feature for water flow; Max. Hot Water Supply: 65 kg/K/s3; Mechanical Parts: Ceramic head part for flow control;Thermostatic cartridge for automatic temperature control;Non-return valve(s);Litter filter(s); Pressure Loss With Flow 02ls: 250000 Pa; Shower Parts: Hand shower;;Adjustable shower rail bracket;Shower hose (1750 mm);Shower rail;Anti limescale technology (easy to clean);Soap dish;Twist guard for shower hose;Variable fixing points; Shower Spray: Normal;Massage;Rain; Shower Spray Number: 3 shower sprays; Surface treatment: Chrome; Temperature Adjustments: Safety stop against scalding at 38°C;The housing of the fittings conducts minimal heat; Working Pressure: 100 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7169N(2023); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass/Plastic; ModelNumber: n/a; ModelReference: 7169N; Name: 7169N Shower faucet with shower set; ReplacementCost: n/a; Shape: Sculptured; Size: 220 x 240 x 180 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - Elevation from Level: 0 mm; FaucetDefaultElevation: 900.078 mm; HandShowerDefaultElevation: 1000 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.364059 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; DistanceX-axis: 0 mm; DistanceY-axis: 0 mm; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.0243698 m3
Identity Data - Mark: 4
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 7169N(2023): 7169N Shower faucet with shower set; Family and Type: 7169N(2023): 7169N Shower faucet with shower set; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7169N(2023): 7169N Shower faucet with shower set; Type Id: 7169N(2023): 7169N Shower faucet with shower set; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
